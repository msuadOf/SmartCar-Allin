# Keil uVision project SmartCar-Allin.uvproj, settings and files
target SmartCar-Allin (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SmartCar-Allin +hex
  group Core
    CORE/Src/: main.c
    ./CORE/Src/: MPU6500.c
  group Driver
    ./Driver/Src/: STC32G_ADC.c STC32G_CAN.c STC32G_Clock.c STC32G_Compare.c STC32G_Delay.c STC32G_DMA.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_LIN.c STC32G_NVIC.c STC32G_PWM.c STC32G_RTC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_USART.c STC32G_WDT.c
    ./Driver/: STC32_MDU32_V1.1.LIB
  group Driver/Isr
    ./Driver/Isr/: STC32G_ADC_Isr.c STC32G_CAN_Isr.c STC32G_Compare_Isr.c STC32G_DMA_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_LCM_Isr.c STC32G_LIN_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c
  group bsp
    ./bsp/: bsp_spi_mpu6500.c bsp_uart.c bsp_gpio.c bsp_pwm_motor.c bsp_adc_dma_timer.c bsp_tim_encoder.c bsp_uart_debug.c
